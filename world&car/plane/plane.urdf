Commit message: cones track training

File: world&car/plane/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=100 100 10; visual mesh filename=plane100.obj scale=1 1 1
